
#include <Wire.h>   // digital inputs, sensor read-in
#include <VL53L1X.h>  // distance sensor control
#include <Servo.h>  // servo control
#include <math.h> // for trig

Servo myservo;
VL53L1X sensor1;
VL53L1X sensor2;


// https://www.google.com/search?q=TOF400C+VL53L1X+what+are+the+distance+modes+and+the+precision+of+each&sca_esv=b7a78c7db20616cf&sxsrf=ANbL-n6QAVx1w5d6RZhYL4iQrKt1D8PK0A%3A1772052443429&ei=21-faeHwGZvx0PEPouHY4QE&biw=1004&bih=897&ved=2ahUKEwjC1_Cq5PWSAxVcAzQIHWB5Fb0Q0NsOegQIAxAB&uact=5&sclient=gws-wiz-serp&fbs=ADc_l-aN0CWEZBOHjofHoaMMDiKpaEWjvZ2Py1XXV8d8KvlI3sbM0Xv-BZKE_VrZb6-djVgPsTSy5UjazDfPq8BLa8BriI08eYAyMPM-9LNl6snbW0RI8x10I65p7k_mDqeHGhWd5G3zo_UP1QuiWQbQdC0uEyj49Iy43Tk0qIMousFs65SKUlmLSf2tVZi7oM3I5JQfNhYdwWzq9bejlmxLE2kuAY1D9A&aep=10&ntc=1&mstk=AUtExfB108WWABR3WGTUoy7MbjRxwzGD9V6Hiufwayk99btRazvaqfD1U-MWqeEHsY6RJaiIhi8pC-TASbp1kZAnLZ6Mtp5_l8g40-E9zW8ok8TE8HB1tzkzfBCqECpcysg8O3VHQeg8r-hPwFE11cNgV6xHo3uAfrB30UosG1Wp5xPn1Rm847Fq7hHl46oGUcXWDuv5jHYXLO3OLbjA0uQOgs5YV-H0dMgBqGncoei0D85JlMWVN0LC_GkXJ-RbUP7gMfG6LmhNc2mufEorT7EGW0Ldufll-7DSpFdlPrZ5ZJEyiZIBF8Lh1XkYSUoQc5P8nL66Crm7ZzNSAQ&csuir=1&mtid=aISfaZ_UILLh0PEP4OiLmQE&udm=50
// may need to re-calibrate.

// Set Constants and create variables
const uint8_t XSHUT_1 = 2;
const uint8_t XSHUT_2 = 3;

const uint8_t ADDR_1 = 0x30;
const uint8_t ADDR_2 = 0x31;

const uint16_t PERIOD_MS = 25;

float D1;
float D2; 
float D_c = 0;  // position from center
float Effort = 0;  // PID effort

float D_set = -90;

float K_p = 1.80;//1.55; //1.5//1.07;    //0.30;  //0.05-0.075    0.12, 0.09
float K_i = 0.05;//0.04; //0.05//0.02;               //Integral Gain    0.00175, 0.003
float K_d = 0.0;//0.0;    //0//0.6 ; ;   //5 ;                 //Derivative Gain   0.2, 0.35               //Derivative Gain   0.2, 0.35

bool alternate_setpoint = true;   // switch between + and - setpoint every t_switch
int t_switch = 90;

float Error = 0;
float int_error = 0;            // Integral error start value
float prev_error = 0;          // 
float der_error = 0;
float prev_der_error = 0;
float last_D_set = D_set;         //remember last loop setpoint for knowing when to reset I

float D_max = 400;  // cap distances when object not found
float allowance = 0;
float r_ball = 25/2;
float D_left_offset  = 214;//260 - r_ball ; //mm
float D_right_offset = 214;//260 - r_ball;



float servo_center = 71;  //71
float servo_pos = 90;         // starting servo position
float MAX_SLEW = 90;


void setup() {
  Serial.begin(115200);
    // Serial.begin(230400);
  Serial1.begin(115200);

  // Wire.setClock(50000);  // lower to 50000 if hard to read from longer wires, default is 100000
  Wire.begin();

  myservo.attach(11);
  myservo.write(servo_center);

  // Shut both sensors down
  pinMode(XSHUT_1, OUTPUT); digitalWrite(XSHUT_1, LOW);
  pinMode(XSHUT_2, OUTPUT); digitalWrite(XSHUT_2, LOW);

  delay(10);

  // ---- Sensor 1 ---- Ball on Beam L
  digitalWrite(XSHUT_1, HIGH);
  delay(10);
  sensor1.init();
  sensor1.setAddress(ADDR_1);
  sensor1.setDistanceMode(VL53L1X::Short);
  sensor1.setMeasurementTimingBudget(1000*PERIOD_MS); 
  sensor1.setROISize(4, 4);
  // sensor1.setROICenter(182); 
  sensor1.startContinuous(PERIOD_MS);

  // ---- Sensor 2 ---- Ball on Beam R
  digitalWrite(XSHUT_2, HIGH);
  delay(10);
  sensor2.init();
  sensor2.setAddress(ADDR_2);
  sensor2.setDistanceMode(VL53L1X::Short);
  sensor2.setMeasurementTimingBudget(1000*PERIOD_MS); 
  sensor2.setROISize(4, 4);
  sensor2.startContinuous(PERIOD_MS);

  Serial.println(F("VL53L1X ready: D1, D2 (Short mode)"));
  Serial.println(F("Format: D1:<mm>\tD2:<mm>\tD3:<mm>"));
}


void loop() {
  // timing - must be first
  static unsigned long t_last = 0;
  unsigned long t_now = micros();
  float dt = (t_now - t_last) / 1000000.0;
  if (dt > 0.5) dt = 0.5;  // clamp first loop
  t_last = t_now;

  if (alternate_setpoint == true) {
    float t = millis() / 1000.0;
    float N = t_switch;  // seconds per half-cycle
    if (fmod(t, 2*N) < N) {
        D_set = abs(D_set);
    } else {
        D_set = -abs(D_set);
    }
  }

  if (last_D_set != D_set){   // reset integral control when setpoint changes
    int_error = 0;
    der_error = 0;
    prev_der_error = 0;
  }


  // Read sensor 1
  sensor1.startContinuous(PERIOD_MS);
  // delay(PERIOD_MS);
  D1 = sensor1.read();
  sensor1.stopContinuous();

  // Read sensor 2 only
  sensor2.startContinuous(PERIOD_MS);
  delay(PERIOD_MS/2);
  D2 = sensor2.read();
  sensor2.stopContinuous();

  // original read-out code, without one-at-a-time multiplexing
  // delay(100);
  // D1 = sensor1.read();   // read() returns distance in mm
  // delay(100);
  // D2 = sensor2.read();

  D1 = min(D_max,D1);       // cap distances
  D2 = min(D_max,D2);

  if (D1 >= 500 && D2 >= 500) {
      D_c = D_set;  // both sensors maxed out, no ball detected, stabalize
  } else if (D1 > 135) {
    // D_c = D_right_offset - D2;
    D_c =  D_right_offset - D2;
  } else {
    D_c = D1 - D_left_offset;
  }
  // } else if (D1 < D2) {
  //   D_c = D1 - D_left_offset ;
  // } else {
  //   D_c = D_right_offset - D2;
  // }

  // ball location PID loop
  prev_error = Error;  // save for next loop
  Error = D_c - D_set;
  // int_error = int_error + Error;        // update integral error 
  int_error = constrain(int_error + Error * dt, -25000.0, 25000.0);
  // float der_error = (Error - prev_error);       // note: 10 frame smoothing already done on T before error
  der_error = 0.7*((Error - prev_error)/dt) + 0.3*prev_der_error;  // adding some smoothing on D
  prev_der_error = der_error;

  float P = K_p * Error;
  float I = K_i * int_error;    // Integral 'effort'
  float D = K_d * der_error;    // Derivative 'effort'
  if (abs(Error) > allowance){
    Effort = P + I + D; 
  } else {
    Effort = P;
    // int_error = 0;      // zero out the integral error   TODO, only if we rest a while, not passing through!
    }             // drop D-control when close to setpoint, to avoid noise kicks


  float theta_set = Effort/1000;
  Serial1.println(theta_set, 4);  // 4 decimal places, in radians

  servo_pos = 45;
  myservo.write(servo_pos);

  // serial monitor
  Serial.print(F("D1:"));
  Serial.print(D1);
  Serial.print(F("\tD2:"));
  Serial.print(D2);


  Serial.print(F("\tD_c:"));
  Serial.print(D_c);
  Serial.print(F("\tD_set:"));
  Serial.print(D_set);
  Serial.print(F("\tP:"));
  Serial.print(P);
  Serial.print(F("\tI:"));
  Serial.print(I);
  Serial.print(F("\tD:"));
  Serial.print(D);
  Serial.print(F("\tE:"));
  Serial.print(Error);
  Serial.print(F("\tEffort:"));
  Serial.print(Effort);
  // Serial.println("");
  Serial.print(F("\tdt_ms:")); Serial.println(dt * 1000.0);
  t_last = t_now;

}
